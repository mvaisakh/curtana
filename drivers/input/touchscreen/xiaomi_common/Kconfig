## drivers/input/touchscreen/xiaomi_common/Kconfig
```kconfig
#
# Xiaomi Common Touchscreen feature
#

source "drivers/input/touchscreen/xiaomi_common/aaabbb/Kconfig"
```
